## defconfig
```kconfig
# Configuration for which patches to apply

CONFIG_KEYBOARD = y
CONFIG_BATTERY = n
```
